options:
  parameters:
    author: Grupo 1
    description: Receptor del proyecto conectado a hardware SDR
    generate_options: qt_gui
    id: Fase4_HackRF_RX_BER_BPSK_Grupo1
    output_language: python
    title: Fase 4 - RX + medicion BER con HackRF - Grupo 1
  states: {}

blocks:
- name: A_imp
  id: variable_qtgui_range
  parameters:
    label: Impulsos del proyecto inyectados en Rx (A_imp)
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: EbN0_max
  id: variable
  parameters:
    value: '14.0'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: EbN0_step
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: N_EbN0
  id: variable
  parameters:
    value: int(round((EbN0_max-EbN0_min)/EbN0_step))+1
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bits_guardia
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: bits_por_punto
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: decim
  id: variable
  parameters:
    value: '125'
  states: {}
- name: delay_bits
  id: variable_qtgui_entry
  parameters:
    label: delay_bits (valor de e_Busca_Retardo)
    type: int
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 960e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nombre_csv
  id: variable
  parameters:
    value: '"curva_BER.csv"'
  states: {}
- name: periodo_imp
  id: variable
  parameters:
    value: '256'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rrc_rx_taps
  id: variable
  parameters:
    value: '[t/sum(x*x for x in rrc_tx_taps) for t in rrc_tx_taps]'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: HackRF RX LNA/IF gain (0-40 dB, pasos de 8)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: HackRF RX VGA/BB gain (0-62 dB, pasos de 2)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (-1+0j, 1+0j)
  states: {}
- name: update_every
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: adapta_tasa
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: interp
    type: ccc
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '500'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: const_rx
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: '""'
    legend: 'False'
    name: '"Constelacion recuperada (tras PFB + Costas)"'
    size: '1024'
    type: complex
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*math.pi/100
  states: {}
- name: curva_ber
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: '"BER"'
    name: '"Curva BER vs Eb/N0 (log10 BER)"'
    update_time: '0.2'
    vlen: N_EbN0
    width1: '3'
    x_axis_label: '"Eb/N0 [dB]"'
    x_start: EbN0_min
    x_step: EbN0_step
    x_units: '"dB"'
    y_axis_label: '"log10(BER)"'
    ymax: '0'
    ymin: '-7'
  states: {}
- name: dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: decision
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_bpsk
  states: {}
- name: desplaza_lo
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: diagrama_ojo
  id: qtgui_eye_sink_x
  parameters:
    grid: 'True'
    label1: I
    label2: Q
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ylabel: Amplitud
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: e_BER_CSV
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from pathlib import Path
      import csv
      import time


      class blk(gr.sync_block):

          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       nombre_archivo="curva_BER.csv",
                       guardar_cada=2.0):

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)

              self.N = int(round(
                  (self.EbN0_max - self.EbN0_min) /
                  self.EbN0_step
              )) + 1

              gr.sync_block.__init__(
                  self,
                  name='Guardar curva BER en CSV',
                  in_sig=[
                      (np.float32, self.N),
                      (np.float32, self.N)
                  ],
                  out_sig=None
              )

              self.nombre_archivo = str(nombre_archivo)
              self.guardar_cada = float(guardar_cada)

              # El Embedded Python Block se genera junto al flowgraph de GNU Radio.
              # Por ello el CSV queda en la misma carpeta contenedora del .grc/.py.
              # Al revisar el bloque en GRC no existe __file__; en ejecucion si.
              try:
                  self.carpeta = Path(__file__).resolve().parent
              except NameError:
                  self.carpeta = Path.cwd()
              self.ruta_csv = self.carpeta / self.nombre_archivo

              self.ultimo_guardado = 0.0
              self.ebn0 = self.EbN0_min + self.EbN0_step * np.arange(self.N)

              print("CSV BER se guardará en:")
              print(self.ruta_csv)

          def guardar(self, ber, logber):
              archivo_temporal = self.ruta_csv.with_suffix(".tmp")

              with open(archivo_temporal, "w", newline="", encoding="utf-8") as f:
                  writer = csv.writer(f)
                  writer.writerow(["EbN0_dB", "BER", "log10_BER"])

                  for eb, b, lb in zip(self.ebn0, ber, logber):
                      writer.writerow([
                          f"{eb:.6f}",
                          f"{float(b):.12e}",
                          f"{float(lb):.12e}"
                      ])

              archivo_temporal.replace(self.ruta_csv)

          def work(self, input_items, output_items):
              ber_vectors = input_items[0]
              log_vectors = input_items[1]

              if len(ber_vectors) == 0:
                  return 0

              ahora = time.time()
              if ahora - self.ultimo_guardado >= self.guardar_cada:
                  self.guardar(ber_vectors[-1], log_vectors[-1])
                  self.ultimo_guardado = ahora

              return len(ber_vectors)
    guardar_cada: '2.0'
    nombre_archivo: nombre_csv
  states: {}
- name: e_BER_Curve
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      """
      e_BER_Curve
      Acumulador de curva BER para los sistemas de los estudiantes.

      Entrada 0 : bits transmitidos de referencia (byte 0/1).
      Entrada 1 : bits recuperados por el receptor (byte 0/1).

      Salida 0  : vector BER lineal.
      Salida 1  : vector log10(BER) para QT GUI Vector Sink.

      El bloque usa exactamente el mismo barrido que e_EbN0_Sweep. Para cada punto:
      - ignora bits_guardia al comienzo del segmento;
      - compara bits_por_punto;
      - cuando el barrido vuelve a un punto, sigue acumulando estadísticas.

      delay_bits retrasa internamente la referencia Tx para compensar el retardo
      del receptor. Se ajusta primero en una condición limpia hasta lograr BER≈0.

      Cuando todavía no se observa ningún error, la salida logarítmica utiliza
      3/N como cota superior aproximada para poder mostrar el punto sin afirmar
      que BER=0.
      """

      import numpy as np
      from collections import deque
      from gnuradio import gr


      class blk(gr.decim_block):  # decim_block: clase Python que GRC 3.10 reconoce
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       delay_bits=0,
                       update_every=1000):
              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.update_every = max(1, int(update_every))

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.N = len(self.eb_axis)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              gr.decim_block.__init__(
                  self,
                  name='e_BER_Curve',
                  in_sig=[np.int8, np.int8],
                  out_sig=[(np.float32, self.N), (np.float32, self.N)],
                  decim=self.update_every
              )

              self.raw_items = 0
              self.count = np.zeros(self.N, dtype=np.int64)
              self.errors = np.zeros(self.N, dtype=np.int64)
              self.delay_bits = delay_bits  # crea la FIFO de la referencia

          # delay_bits se puede cambiar durante la ejecucion (QT GUI Entry):
          # al cambiarlo se vacia la FIFO y se reinician las estadisticas.
          @property
          def delay_bits(self):
              return self._delay_bits

          @delay_bits.setter
          def delay_bits(self, valor):
              self._delay_bits = max(0, int(valor))
              self.tx_fifo = deque([0]*self._delay_bits)
              self.saltar = self._delay_bits
              self.count[:] = 0
              self.errors[:] = 0

          def _process(self, tx, rx):
              for t, r in zip(tx, rx):
                  tb = int(t) & 1
                  rb = int(r) & 1

                  if self._delay_bits > 0:
                      self.tx_fifo.append(tb)
                      t_aligned = self.tx_fifo.popleft()
                  else:
                      t_aligned = tb

                  # El indice de bit cuenta todos los bits recibidos, para que los
                  # segmentos coincidan con los del barrido de e_EbN0_Sweep aunque
                  # delay_bits sea grande (en hardware puede llegar a ~32767).
                  bit_index = self.raw_items
                  self.raw_items += 1
                  if self.saltar > 0:
                      self.saltar -= 1
                      continue

                  segment_index = bit_index // self.segment_bits
                  point_index = segment_index % self.N
                  pos = bit_index % self.segment_bits

                  # Dejar que filtros/sincronizadores se estabilicen después
                  # del cambio de nivel de ruido.
                  if pos >= self.bits_guardia:
                      self.count[point_index] += 1
                      if t_aligned != rb:
                          self.errors[point_index] += 1

          def _vectors(self):
              ber = np.zeros(self.N, dtype=np.float32)
              logber = np.zeros(self.N, dtype=np.float32)

              for i in range(self.N):
                  n = int(self.count[i])
                  e = int(self.errors[i])

                  if n <= 0:
                      ber[i] = 0.0
                      logber[i] = 0.0
                  elif e > 0:
                      b = e/float(n)
                      ber[i] = b
                      logber[i] = np.log10(max(b, 1e-12))
                  else:
                      # BER observado = 0; para la gráfica usamos una cota superior.
                      ber[i] = 0.0
                      upper = min(1.0, 3.0/float(n))
                      logber[i] = np.log10(max(upper, 1e-12))

              return ber, logber

          def work(self, input_items, output_items):
              tx = input_items[0]
              rx = input_items[1]
              out_ber = output_items[0]
              out_log = output_items[1]

              nout = len(out_ber)
              D = self.update_every

              for k in range(nout):
                  a = k*D
                  b = min((k+1)*D, len(tx))
                  if a < b:
                      self._process(tx[a:b], rx[a:b])

                  ber, logber = self._vectors()
                  out_ber[k, :] = ber
                  out_log[k, :] = logber

              return nout
    bits_guardia: bits_guardia
    bits_por_punto: bits_por_punto
    delay_bits: delay_bits
    update_every: update_every
  states: {}
- name: e_Busca_Retardo
  id: epy_block
  parameters:
    _source_code: |
      """
      e_Busca_Retardo (Grupo 1)
      Herramienta de apoyo para calibrar delay_bits en el laboratorio.

      Entrada 0 : bits Tx de referencia (byte 0/1).
      Entrada 1 : bits Rx recuperados (byte 0/1).

      Acumula 'n_bits' de cada secuencia y calcula, por correlación cruzada (FFT),
      el retardo (en bits) que mejor alinea Rx con Tx, entre 0 y 'max_lag'.
      Imprime en la consola de GNU Radio el retardo y la BER en ese retardo.
      Si la correlación es negativa, los bits llegan invertidos (ambigüedad de 180°).
      Se repite cada 'n_bits' bits.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, n_bits=40000, max_lag=33000):
              gr.sync_block.__init__(self, name='e_Busca_Retardo',
                                     in_sig=[np.int8, np.int8], out_sig=None)
              self.n_bits = int(n_bits)
              self.max_lag = int(max_lag)
              self.tx = []
              self.rx = []
              self.total = self.n_bits + self.max_lag

          def work(self, input_items, output_items):
              self.tx.extend((input_items[0] & 1).tolist())
              self.rx.extend((input_items[1] & 1).tolist())
              if len(self.tx) >= self.total and len(self.rx) >= self.total:
                  tx = 2.0*np.array(self.tx[:self.total]) - 1.0
                  rx = 2.0*np.array(self.rx[self.max_lag:self.total]) - 1.0
                  n = 1 << int(np.ceil(np.log2(len(tx) + len(rx))))
                  corr = np.fft.irfft(np.fft.rfft(tx, n) * np.conj(np.fft.rfft(rx, n)), n)
                  c = corr[:self.max_lag + 1][::-1] / len(rx)
                  k = int(np.argmax(np.abs(c)))
                  lag = k
                  ref = tx[self.max_lag - lag:self.max_lag - lag + len(rx)]
                  ber = float(np.mean(np.sign(ref) != np.sign(rx)))
                  print(f"[e_Busca_Retardo] delay_bits = {lag}  correlacion = {c[k]:+.3f}  BER en ese retardo = {ber:.3e}"
                        + ("  (bits INVERTIDOS)" if c[k] < 0 else ""))
                  self.tx = self.tx[self.total:]
                  self.rx = self.rx[self.total:]
              return len(input_items[0])
    max_lag: '33000'
    n_bits: '40000'
  states: {}
- name: e_EbN0_Sweep
  id: epy_block
  parameters:
    EbN0_max: EbN0_max
    EbN0_min: EbN0_min
    EbN0_step: EbN0_step
    _source_code: |
      """
      e_EbN0_Sweep
      Instrumento para caracterización BER con un enlace SDR ya funcional.

      Entrada 0 : señal compleja I/Q recibida del SDR (preferiblemente DESPUÉS
                  de la adaptación radio_rate -> bb_rate).
      Salida 0  : la misma señal I/Q con AWGN adicional controlado.
      Salida 1  : valor instantáneo de Eb/N0 [dB] usado en el barrido.

      El bloque NO sustituye el USRP/HackRF ni el receptor. Se inserta entre
      la salida I/Q del SDR y la entrada del receptor digital.

      El barrido se hace por segmentos contiguos. Cada punto se mantiene durante:
          bits_guardia + bits_por_punto

      La potencia de ruido artificial se calcula a partir de la potencia promedio
      medida ANTES de agregar el ruido:

          Eb = Ps / Rb
          N0 = Eb / (Eb/N0)
          Pn = N0 * Fs

      por lo tanto:

          Pn = Ps * Fs / (Rb * 10**(EbN0_dB/10))

      El ruido complejo se genera con varianza total Pn.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       samp_rate=256000.0,
                       bit_rate=64000.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       signal_power=0.0,
                       seed=2026):
              gr.sync_block.__init__(
                  self,
                  name='e_EbN0_Sweep',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32]
              )

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.samp_rate = float(samp_rate)
              self.bit_rate = float(bit_rate)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.signal_power_cfg = float(signal_power)

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.samp_rate <= 0 or self.bit_rate <= 0:
                  raise ValueError("samp_rate y bit_rate deben ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              self.sample_count = 0
              self.power_sum = 0.0
              self.power_count = 0
              self.rng = np.random.default_rng(int(seed))

          def _signal_power(self, x):
              if self.signal_power_cfg > 0:
                  return self.signal_power_cfg

              # Promedio acumulado de la señal recibida ANTES del ruido artificial.
              self.power_sum += float(np.sum(np.abs(x.astype(np.complex128))**2))
              self.power_count += len(x)
              if self.power_count <= 0:
                  return 0.0
              return max(self.power_sum/self.power_count, 1e-20)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              eb_out = output_items[1]
              n = len(x)
              if n == 0:
                  return 0

              Ps = self._signal_power(x)

              # Índice absoluto de muestra -> índice equivalente de bit.
              s = self.sample_count + np.arange(n, dtype=np.float64)
              bit_index = np.floor(s*self.bit_rate/self.samp_rate).astype(np.int64)

              segment_index = bit_index // self.segment_bits
              point_index = np.mod(segment_index, len(self.eb_axis))
              ebn0_db = self.eb_axis[point_index]
              ebn0_lin = np.power(10.0, ebn0_db/10.0)

              # Potencia total del ruido complejo por muestra.
              noise_power = Ps*self.samp_rate/(self.bit_rate*ebn0_lin)
              sigma_iq = np.sqrt(np.maximum(noise_power, 0.0)/2.0)

              noise = (
                  self.rng.standard_normal(n)*sigma_iq
                  + 1j*self.rng.standard_normal(n)*sigma_iq
              ).astype(np.complex64)

              y[:] = x + noise
              eb_out[:] = ebn0_db.astype(np.float32)

              self.sample_count += n
              return n
    bit_rate: Rb
    bits_guardia: bits_guardia
    bits_por_punto: bits_por_punto
    samp_rate: samp_rate
    seed: '2026'
    signal_power: '0.0'
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: 2*math.pi/400
  states: {}
- name: fuente_ref
  id: digital_glfsr_source_x
  parameters:
    degree: '15'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"hackrf=0"'
    bb_gain0: rx_vga
    freq0: fc + lo_off
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_lna
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: impulsos
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0j]*(periodo_imp-1) + [complex(A_imp, 0)]'
  states: {}
- name: null_costas
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: null_ebn0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: null_fll
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: null_pfb
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: pfb_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, Rs, beta, span*Sps*nfilts)
    type: ccf
  states: {}
- name: psd_rx_radio
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    label1: Senal
    name: '"Espectro recibido (radio_rate, despues de quitar lo_off)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: rrc_rx_ojo
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_rx_taps
    type: ccf
  states: {}
- name: suma_impulsos
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}

connections:
- [adapta_tasa, '0', suma_impulsos, '0']
- [agc, '0', fll, '0']
- [agc, '0', rrc_rx_ojo, '0']
- [costas, '0', const_rx, '0']
- [costas, '0', decision, '0']
- [costas, '1', null_costas, '0']
- [dec_diferencial, '0', e_BER_Curve, '1']
- [dec_diferencial, '0', e_Busca_Retardo, '1']
- [decision, '0', dec_diferencial, '0']
- [desplaza_lo, '0', adapta_tasa, '0']
- [desplaza_lo, '0', psd_rx_radio, '0']
- [e_BER_Curve, '0', e_BER_CSV, '0']
- [e_BER_Curve, '1', curva_ber, '0']
- [e_BER_Curve, '1', e_BER_CSV, '1']
- [e_EbN0_Sweep, '0', agc, '0']
- [e_EbN0_Sweep, '1', null_ebn0, '0']
- [fll, '0', pfb_sync, '0']
- [fll, '1', null_fll, '0']
- [fll, '2', null_fll, '1']
- [fll, '3', null_fll, '2']
- [fuente_ref, '0', e_BER_Curve, '0']
- [fuente_ref, '0', e_Busca_Retardo, '0']
- [hackrf_source, '0', desplaza_lo, '0']
- [impulsos, '0', suma_impulsos, '1']
- [pfb_sync, '0', costas, '0']
- [pfb_sync, '1', null_pfb, '0']
- [pfb_sync, '2', null_pfb, '1']
- [pfb_sync, '3', null_pfb, '2']
- [rrc_rx_ojo, '0', diagrama_ojo, '0']
- [suma_impulsos, '0', e_EbN0_Sweep, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
