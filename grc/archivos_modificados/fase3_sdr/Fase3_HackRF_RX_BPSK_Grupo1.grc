options:
  parameters:
    author: Grupo 1
    description: Receptor del proyecto conectado a hardware SDR
    generate_options: qt_gui
    id: Fase3_HackRF_RX_BPSK_Grupo1
    output_language: python
    title: Fase 3 - RX BPSK con HackRF - Grupo 1
  states: {}

blocks:
- name: A_imp
  id: variable_qtgui_range
  parameters:
    label: Impulsos del proyecto inyectados en Rx (A_imp)
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: adapta_tasa
  id: rational_resampler_xxx
  parameters:
    interp: interp
    decim: decim
    type: ccc
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '500'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: beta
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: const_rx
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    label1: '""'
    legend: 'False'
    name: '"Constelacion recuperada (tras PFB + Costas)"'
    size: '1024'
    type: complex
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*math.pi/100
  states: {}
- name: dec_diferencial
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: decim
  id: variable
  parameters:
    value: '125'
  states: {}
- name: decision
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const_bpsk
  states: {}
- name: desplaza_lo
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: diagrama_ojo
  id: qtgui_eye_sink_x
  parameters:
    name: '"Diagrama de ojo (filtro acoplado, sin recuperar portadora)"'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymin: '-1.6'
    ymax: '1.6'
    grid: 'True'
    label1: I
    label2: Q
    ylabel: Amplitud
  states: {}
- name: fc
  id: variable
  parameters:
    value: 960e6
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: 2*math.pi/400
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    sample_rate: radio_rate
    freq0: fc + lo_off
    gain_mode0: 'False'
    gain0: '0'
    if_gain0: rx_lna
    bb_gain0: rx_vga
    ant0: '""'
    sync: none
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: impulsos
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[0j]*(periodo_imp-1) + [complex(A_imp, 0)]'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '16'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: null_bits
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: null_costas
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: null_fll
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: null_pfb
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: periodo_imp
  id: variable
  parameters:
    value: '256'
  states: {}
- name: pfb_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts*samp_rate, Rs, beta, span*Sps*nfilts)
    type: ccf
  states: {}
- name: psd_rx_radio
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    label1: Senal
    name: '"Espectro recibido (radio_rate, despues de quitar lo_off)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rrc_rx_ojo
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_rx_taps
    type: ccf
  states: {}
- name: rrc_rx_taps
  id: variable
  parameters:
    value: '[t/sum(x*x for x in rrc_tx_taps) for t in rrc_tx_taps]'
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    gain: Sps
    samp_rate: samp_rate
    sym_rate: Rs
    alpha: beta
    ntaps: span*Sps
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: HackRF RX LNA/IF gain (0-40 dB, pasos de 8)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: HackRF RX VGA/BB gain (0-62 dB, pasos de 2)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: suma_impulsos
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (-1+0j, 1+0j)
  states: {}

connections:
- [hackrf_source, '0', desplaza_lo, '0']
- [desplaza_lo, '0', adapta_tasa, '0']
- [adapta_tasa, '0', suma_impulsos, '0']
- [impulsos, '0', suma_impulsos, '1']
- [suma_impulsos, '0', agc, '0']
- [agc, '0', fll, '0']
- [fll, '0', pfb_sync, '0']
- [pfb_sync, '0', costas, '0']
- [costas, '0', decision, '0']
- [decision, '0', dec_diferencial, '0']
- [fll, '1', null_fll, '0']
- [fll, '2', null_fll, '1']
- [fll, '3', null_fll, '2']
- [pfb_sync, '1', null_pfb, '0']
- [pfb_sync, '2', null_pfb, '1']
- [pfb_sync, '3', null_pfb, '2']
- [costas, '1', null_costas, '0']
- [dec_diferencial, '0', null_bits, '0']
- [desplaza_lo, '0', psd_rx_radio, '0']
- [agc, '0', rrc_rx_ojo, '0']
- [rrc_rx_ojo, '0', diagrama_ojo, '0']
- [costas, '0', const_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
