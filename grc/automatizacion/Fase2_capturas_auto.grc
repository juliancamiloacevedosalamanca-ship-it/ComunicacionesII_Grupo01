options:
  parameters:
    author: Grupo 1
    comment: 'Tx: PRBS -> BPSK -> RRC. Canal: AWGN + tren de impulsos (1 cada 256 muestras). Rx: RRC acoplado -> ojo -> muestreo 1 de Sps (offset) -> decision -> bits. Validacion: XOR con bits Tx retardados.'
    description: 'S1 Telemetria industrial: BPSK con RRC, canal AWGN + ruido impulsivo y receptor con filtro acoplado'
    generate_options: qt_gui
    id: Fase2_capturas_auto
    output_language: python
    title: Fase 2 - Enlace BPSK Tx-Canal-Rx (Grupo 1, S1)
  states: {}

blocks:
- name: A_imp
  id: variable_qtgui_range
  parameters:
    label: Amplitud del impulso A_imp (A=0, B=0.3, C=0.6, D=1.0)
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: Rb = 32 kb/s
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    comment: Tasa de simbolos [sym/s]
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    comment: Muestras por simbolo
    value: '8'
  states: {}
- name: ber_ventana
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '4000'
    scale: 1.0/100000
    type: float
  states: {}
- name: beta
  id: variable
  parameters:
    comment: Roll-off RRC
    value: '0.35'
  states: {}
- name: bits_rx_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_tx_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_tx_rx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs@2: 1,0,1,1'
    label1: Tx
    label2: Rx
    name: '"Bits Tx (abajo, retardados 11) vs bits Rx (arriba, +1.5)"'
    nconnections: '2'
    size: '64'
    srate: Rb
    type: float
    ymax: '3'
    ymin: '-0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: comparador_xor
  id: blocks_xor_xx
  parameters:
    type: byte
    vlen: '1'
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: const_recuperada
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs@1: 0,1,1,1'
    label1: '""'
    legend: 'False'
    name: '"Constelacion recuperada (1 muestra por simbolo)"'
    size: '1024'
    type: complex
    xmax: '1.6'
    xmin: '-1.6'
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: decision
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decision por minima distancia (umbral I = 0)
    constellation: const_bpsk
  states: {}
- name: desplaza_rx
  id: blocks_add_const_vxx
  parameters:
    comment: 'Solo para graficar: bits Rx desplazados +1.5'
    const: '1.5'
    type: float
  states: {}
- name: diagrama_ojo
  id: qtgui_eye_sink_x
  parameters:
    name: '"Diagrama de ojo a la salida del filtro acoplado"'
    gui_hint: 'tabs@1: 0,0,1,1'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymin: '-1.6'
    ymax: '1.6'
    grid: 'True'
    label1: I
    label2: Q
    ylabel: Amplitud
  states: {}
- name: errores_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: fuente_bits
  id: digital_glfsr_source_x
  parameters:
    comment: PRBS-15 (secuencia conocida, repetible en Tx y Rx)
    type: byte
    degree: '15'
    mask: '0'
    repeat: 'True'
    seed: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: impulsos
  id: blocks_vector_source_x
  parameters:
    comment: Ruido impulsivo controlado
    repeat: 'True'
    type: complex
    vector: '[0j]*(periodo_imp-1) + [complex(A_imp, 0)]'
  states: {}
- name: iq_sobremuestreado
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs@0: 1,1,1,1'
    label1: '""'
    legend: 'False'
    name: '"Plano I-Q sobremuestreado (antes del Rx, NO son decisiones)"'
    size: '2048'
    type: complex
    xmax: '2.5'
    xmin: '-2.5'
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: mapeo_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: medidor_ber
  id: qtgui_number_sink
  parameters:
    name: '"BER (ventana de 100 000 bits)"'
    gui_hint: 'tabs@2: 0,0,1,1'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    max: '0.5'
    update_time: '0.2'
    label1: '""'
    decimal: '6'
  states: {}
- name: muestreo_simbolo
  id: blocks_keep_m_in_n
  parameters:
    comment: 'Muestreo: 1 muestra por simbolo en el maximo del ojo'
    m: '1'
    n: Sps
    offset: offset_muestreo
    type: complex
    vlen: '1'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: 0.10 = condicion base del proyecto
    label: Amplitud AWGN del canal
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.10'
  states: {}
- name: offset_muestreo
  id: variable_qtgui_range
  parameters:
    comment: 0 = maximo del ojo (retardo total Tx+Rx = 88 muestras = 11 simbolos)
    label: Instante de muestreo (offset 0-7 dentro del simbolo)
    rangeType: int
    start: '0'
    step: '1'
    stop: '7'
    value: '0'
  states: {}
- name: periodo_imp
  id: variable
  parameters:
    comment: 1 impulso cada 256 muestras = 1 ms
    value: '256'
  states: {}
- name: psd_tx_canal
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'tabs@0: 0,0,1,2'
    label1: RRC Tx
    label2: Canal
    name: '"PSD: salida RRC Tx (azul) y salida del canal (rojo)"'
    nconnections: '2'
    type: complex
    ymin: '-100'
  states: {}
- name: retardo_bits
  id: variable
  parameters:
    comment: Retardo total del enlace en bits (calibrado con BER = 0 en condicion limpia)
    value: '11'
  states: {}
- name: retardo_ref
  id: blocks_delay
  parameters:
    delay: retardo_bits
    type: byte
  states: {}
- name: rrc_rx_acoplado
  id: fir_filter_xxx
  parameters:
    comment: Filtro acoplado RRC (Rx)
    decim: '1'
    taps: rrc_rx_taps
    type: ccf
  states: {}
- name: rrc_rx_taps
  id: variable
  parameters:
    comment: 'Filtro acoplado: RRC normalizado por su energia -> pico de decision = +-1'
    value: '[t/sum(x*x for x in rrc_tx_taps) for t in rrc_tx_taps]'
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    comment: Conformacion de pulso RRC (Tx)
    interp: Sps
    taps: rrc_tx_taps
    type: ccf
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    comment: 'RRC Tx: ganancia Sps -> nivel de simbolo ~1 (GNU Radio fuerza 89 taps impares)'
    gain: Sps
    samp_rate: samp_rate
    sym_rate: Rs
    alpha: beta
    ntaps: span*Sps
  states: {}
- name: ruido_awgn
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: bb_rate = Rs*Sps = 256 kS/s
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    comment: Longitud del RRC en simbolos
    value: '11'
  states: {}
- name: suma_awgn
  id: blocks_add_xx
  parameters:
    comment: 'Canal: + AWGN'
    type: complex
  states: {}
- name: suma_impulsos
  id: blocks_add_xx
  parameters:
    comment: 'Canal: + impulsos'
    type: complex
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    comment: 'BPSK: bit 0 -> -1, bit 1 -> +1'
    value: (-1+0j, 1+0j)
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    num_tabs: '3'
    label0: Transmisor y canal
    label1: Receptor
    label2: Validacion bits Tx vs Rx
  states: {}
- name: throttle_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tiempo_canal
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs@0: 1,0,1,1'
    label1: I
    label2: Q
    name: '"Envolvente compleja a la salida del canal"'
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: tiempo_mf
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'tabs@1: 1,0,1,2'
    label1: I
    label2: Q
    name: '"Salida del filtro acoplado (I) y muestras decididas"'
    size: '512'
    srate: samp_rate
    type: complex
    ymax: '1.6'
    ymin: '-1.6'
  states: {}
- name: capturas
  id: epy_module
  parameters:
    comment: Automatizacion de capturas
    source_code: |
      """
      Capturas automaticas de la Fase 2 (Grupo 1, S1).
      Recorre las pruebas del proyecto, cambia A_imp y el instante de muestreo,
      y guarda una imagen de cada pestana de la ventana QT en la carpeta
      capturas_fase2/ (junto al .grc). Tambien guarda la BER medida en un CSV.
      Al terminar cierra la ventana.
      """
      import os, sys, csv, time
      from PyQt5 import QtCore, QtWidgets

      PRUEBAS = [
          # etiqueta,              A_imp, offset de muestreo, noise_amp
          ('0_ideal_sin_ruido',     0.0, 0, 0.0),
          ('A_ref_Aimp_0.0',        0.0, 0),
          ('B_suave_Aimp_0.3',      0.3, 0),
          ('C_media_Aimp_0.6',      0.6, 0),
          ('D_fuerte_Aimp_1.0',     1.0, 0),
          ('E_extrema_Aimp_5.0',    5.0, 0),
          ('F_Aimp_0.0_offset_4',   0.0, 4),
      ]
      ESPERA_MS = 9000      # > ventana de BER (100 000 bits = 3.1 s) + retardo del promedio
      ESPERA_TAB_MS = 2500

      def iniciar(env):
          tb = env.get('self') or env.get('tb')
          carpeta = os.path.join(os.path.dirname(os.path.abspath(sys.argv[0])), 'capturas_fase2')
          os.makedirs(carpeta, exist_ok=True)
          tb.resize(1600, 1000)
          filas = []
          estado = {'i': 0}

          def grab(nombre):
              QtWidgets.QApplication.processEvents()
              tb.grab().save(os.path.join(carpeta, nombre), 'PNG')

          def siguiente():
              i = estado['i']
              if i >= len(PRUEBAS):
                  with open(os.path.join(carpeta, 'ber_fase2.csv'), 'w', newline='') as f:
                      w = csv.writer(f); w.writerow(['prueba', 'A_imp', 'offset', 'noise_amp', 'BER_ventana_100k'])
                      w.writerows(filas)
                  print('[capturas] listo ->', carpeta, flush=True)
                  QtCore.QTimer.singleShot(1000, tb.close)
                  return
              tag, A, off = PRUEBAS[i][:3]
              ruido = PRUEBAS[i][3] if len(PRUEBAS[i]) > 3 else 0.10
              tb.set_noise_amp(ruido); tb.set_A_imp(A); tb.set_offset_muestreo(off)
              print('[capturas] prueba', tag, flush=True)
              QtCore.QTimer.singleShot(ESPERA_MS, lambda: pestana(0))

          def pestana(k):
              tag, A, off = PRUEBAS[estado['i']][:3]
              tb.tabs.setCurrentIndex(k)
              def tomar():
                  grab('fase2_%s_pestana%d.png' % (tag, k + 1))
                  if k < 2:
                      pestana(k + 1)
                  else:
                      ber = float(tb.sonda_ber.level())
                      filas.append([tag, A, off, tb.get_noise_amp(), '%.6g' % ber])
                      print('[capturas] %s BER = %.6g' % (tag, ber), flush=True)
                      estado['i'] += 1
                      siguiente()
              QtCore.QTimer.singleShot(ESPERA_TAB_MS, tomar)

          QtCore.QTimer.singleShot(3000, siguiente)
  states: {}
- name: snippet_capturas
  id: snippet
  parameters:
    code: capturas.iniciar(locals())
    section: main_after_start
  states: {}
- name: sonda_ber
  id: blocks_probe_signal_x
  parameters:
    comment: Lee la BER para el registro
    type: float
  states: {}

connections:
- [fuente_bits, '0', mapeo_bpsk, '0']
- [mapeo_bpsk, '0', rrc_tx, '0']
- [rrc_tx, '0', throttle_0, '0']
- [throttle_0, '0', suma_awgn, '0']
- [ruido_awgn, '0', suma_awgn, '1']
- [suma_awgn, '0', suma_impulsos, '0']
- [impulsos, '0', suma_impulsos, '1']
- [suma_impulsos, '0', rrc_rx_acoplado, '0']
- [rrc_rx_acoplado, '0', muestreo_simbolo, '0']
- [muestreo_simbolo, '0', decision, '0']
- [fuente_bits, '0', retardo_ref, '0']
- [retardo_ref, '0', comparador_xor, '0']
- [decision, '0', comparador_xor, '1']
- [comparador_xor, '0', errores_float, '0']
- [errores_float, '0', ber_ventana, '0']
- [ber_ventana, '0', medidor_ber, '0']
- [retardo_ref, '0', bits_tx_float, '0']
- [decision, '0', bits_rx_float, '0']
- [bits_rx_float, '0', desplaza_rx, '0']
- [bits_tx_float, '0', bits_tx_rx, '0']
- [desplaza_rx, '0', bits_tx_rx, '1']
- [rrc_tx, '0', psd_tx_canal, '0']
- [suma_impulsos, '0', psd_tx_canal, '1']
- [suma_impulsos, '0', tiempo_canal, '0']
- [suma_impulsos, '0', iq_sobremuestreado, '0']
- [rrc_rx_acoplado, '0', diagrama_ojo, '0']
- [muestreo_simbolo, '0', const_recuperada, '0']
- [rrc_rx_acoplado, '0', tiempo_mf, '0']
- [ber_ventana, '0', sonda_ber, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
